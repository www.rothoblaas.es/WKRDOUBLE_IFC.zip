Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 7a7cecb2-f627-41e6-9c57-839a8d0927e9, NumberOfSaves: 3], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Plate_WKRD100C_WHTW6016_35mm.ifc
Time: 2026-03-09T12:18:17
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDiscreteAccessory: Structural Connections : ROTHOB_Rothoblaas_Plate_WHT_Washer : WHTW6016_50x56mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_WHT_Washer; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/angle-brackets-and-plates-for-buildings/wht; Revision: n/a; UniClass2015Code: Pr_20_85_09_11; UniClass2015Title: Carbon steel brackets; UniClass2015Version: Products v1.33; Version: 3
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 6016
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - Dimensions - Base_Br: 50 mm; Depth_Pr: 56 mm; HoleDiameter_Ø3: 18 mm; Thickness_sr: 6 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: WHTW6016_50x56mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-23/0813; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Angle bracket for tensile loads; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_WHT_Washer; Features: Angle bracket for tensile forces for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: Zinc plated; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: Temporarily not available; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: WHTW6016; ModelReference: n/a; Name: Plate; NominalDepth: 56 mm; NominalHeight: n/a; NominalWidth: 50 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 50x56 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_ProductRequirements - Name: Plate
Pset_QuantityTakeOff - Reference: WHTW6016_50x56mm
Constraints - Moves With Nearby Elements: no
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.0000152732 m3
Other - Family: ROTHOB_Rothoblaas_Plate_WHT_Washer; Family and Type: ROTHOB_Rothoblaas_Plate_WHT_Washer: WHTW6016_50x56mm; Type: WHTW6016_50x56mm; Type Id: 376389

# IfcDiscreteAccessory: Structural Connections : ROTHOB_Rothoblaas_Plate_WKRD100C : WKRD100C_68x255x100mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_S355-Fe/Zn12c
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_WKRD100C; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/angle-brackets-and-plates-for-buildings/wkr-double; Revision: 000; UniClass2015Code: Pr_20_85_09_11; UniClass2015Title: Carbon steel brackets; UniClass2015Version: Products v1.38; Version: 001
Type - Constraints - Default Elevation: 1219.2 mm; Washer_Type_WHTW6016: ROTHOB_Rothoblaas_Plate_WHT_Washer : WHTW6016_50x56mm; Washer_Type_WHTW6020: ROTHOB_Rothoblaas_Plate_WHT_Washer : WHTW6020_50x56mm; Washer_Type_WKRDW: ROTHOB_Rothoblaas_Plate_WKRDW : WKRDW6020_240x54x15mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S355-Fe/Zn12c
Type - Dimensions - BaseHoleDiameter: 23 mm; Height_H: 100 mm; HoleDiameter: 6.5 mm; HoleQuantity_nhØ23: 1; HoleQuantity_nvØ6.5: 6; Length_L: 255 mm; Width_B: 68 mm
Type - Identity Data - Description: Tensile angle bracket for prefabricated walls; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.13.23.11.19.13; Type Name: WKRD100C_68x255x100mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: ETA-22/0089; CETitle: Rotho Blaas NINO Angle Brackets, WKR and WKRD Hold Downs; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description_2: Tensile angle bracket for prefabricated walls; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_WKRD100C; Features: Base angle bracket; Finish: n/a; Grade: n/a; GTIN: 8054045438795 / WKRDW6020: 8054045438788; Manufacturer_2: info@rothoblaas.com; Material: Carbon steel S355 + Fe/Zn12c; MinWeight: 1.175 kg / WKRDW6020 1.830 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: WKRD100C; ModelReference: n/a; Name: Plate; NominalHeight: 100 mm; NominalLength: 255 mm; NominalWidth: 68 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 68x255x100 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate
Pset_QuantityTakeOff - Reference: WKRD100C_68x255x100mm
Visibility - Washer: yes; Washer_Type: ROTHOB_Rothoblaas_Plate_WHT_Washer : WHTW6016_50x56mm
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0397438 m2; Volume: 0.000149791 m3; WasherPositioning: 35 mm; WasherPositioning_Ctrl: 35 mm
Other - Family: ROTHOB_Rothoblaas_Plate_WKRD100C; Family and Type: ROTHOB_Rothoblaas_Plate_WKRD100C: WKRD100C_68x255x100mm; Type: WKRD100C_68x255x100mm; Type Id: 376565
